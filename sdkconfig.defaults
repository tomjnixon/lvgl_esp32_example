## sdkconfig.defaults
```kconfig
CONFIG_LV_HOR_RES_MAX=320
CONFIG_LV_VER_RES_MAX=240
CONFIG_LV_COLOR_16_SWAP=y

# makes the demo a bit more usable
CONFIG_LV_DEMO_WIDGETS_SLIDESHOW=n
```
